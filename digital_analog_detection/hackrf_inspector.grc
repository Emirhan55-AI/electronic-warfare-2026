options:
  parameters:
    generate_options: qt_gui
    id: hackrf_inspector
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2e6
    fc: 435e6
    fftsize: '2048'
    grid: 'True'
    type: complex
    update_time: '0.1'
    wintype: window.WIN_FLATTOP
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: ' samp_rate'
    center_freq: 435e6
    dev_args: serial=a32868dc36877e47
    gain: '24'
    samp_rate: 2e6
    type: fc32
    vga: '20'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: complex
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
