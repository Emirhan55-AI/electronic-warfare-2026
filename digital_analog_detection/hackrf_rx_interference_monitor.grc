options:
  parameters:
    description: 'Yalnız RX: spektrum, spektrogram ve I/Q zaman alanı gözlemi. TX bloğu içermez.'
    generate_options: qt_gui
    id: hackrf_rx_interference_monitor
    output_language: python
    sizing_mode: auto
    title: HackRF RX - Sinyal Bozulması Gözlemi
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: USB kararlılığı için başlangıç değeri; bu akış yalnız alıcıdır.
    value: 2e6
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Merkez frekansı (Hz)
    min_len: '400'
    start: 1e6
    step: 100e3
    stop: 6e9
    value: 1900e6
    widget: eng
  states: {}
- name: lna_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: LNA kazancı (dB)
    min_len: '250'
    rangeType: int
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: VGA kazancı (dB)
    min_len: '250'
    rangeType: int
    start: '0'
    step: '2'
    stop: '62'
    value: '16'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: center_freq
    comment: Yalnız RX. AMP kapalı; TX sink veya RF çıkışı yoktur.
    dev_args: serial=a32868dc36877e47
    gain: lna_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.20'
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 2,0,2,2
    label: Spektrum
    label1: Alınan sinyal
    legend: 'False'
    type: complex
    units: dBFS
    wintype: window.WIN_HANN
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 4,0,3,2
    int_max: '0'
    int_min: '-120'
    label1: Alınan sinyal
    legend: 'False'
    name: '"Spektrogram"'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 7,0,2,2
    label1: I
    label2: Q
    name: '"I/Q zaman alanı"'
    srate: samp_rate
    size: '2048'
    type: complex
    ylabel: Bağıl genlik
  states: {}

connections:
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
